FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_dm800 += "file://bypass-ip6-structures-declarations.patch"
