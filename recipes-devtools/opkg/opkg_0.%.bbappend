FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_dm800 += "file://revert-commit-7a8c2f6.patch"
